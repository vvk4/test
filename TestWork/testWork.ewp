# IAR project testWork.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ; board\; Libraries\CMSIS\Device\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; FreeRTOSv202212.00\FreeRTOS\Source\include; FreeRTOSv202212.00\FreeRTOS\Source\portable\IAR\ARM_CM4F; FreeRTOSv202212.00\FreeRTOS\Demo\Common\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: FreeRTOSConfig.h main.c stm32f4xx_it.c
  group FreeRTOS_Source
    FreeRTOSv202212.00/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/Portable
    FreeRTOSv202212.00/FreeRTOS/Source/portable/MemMang/: heap_4.c
    FreeRTOSv202212.00/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group ST_and_IAR_code/startup
    startup/: startup_stm32f4xx.s system_stm32f4xx.c
  group ST_and_IAR_code/STM32F4xx_StdPeriph_Driver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group testWorkFiles
    ./: adcTest.cpp ledTest.cpp uartTest.cpp
